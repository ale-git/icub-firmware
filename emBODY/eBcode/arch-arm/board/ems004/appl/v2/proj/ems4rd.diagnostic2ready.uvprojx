# Keil uVision project ems4rd.diagnostic2ready.uvprojx, settings and files
target ems4rd-zero (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ems4rd-zero +hex
  AfterMake: cmd.exe /C copy .\Obj\ems4rd-zero.hex ..\bin\ems4rd-zero.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NOT_ICUB_GENOVA04 ICUB_DARMSTADT01 EOPROT_USE_MN_VERSION_2_0 HAL_IS_VERSION_2 USE_PROTO_PROXY EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO
  c misc: -DemBODYrobot_ROBOT_NAME=icubANY -DemBODYrobot_BOARD_NAME=boardEMS4RD -DemBODYrobot_BOARD_NUMBER=boardnumberANY
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg\eoemsappl;..\cfg\abslayer;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\src;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\embobj\plus\board\ems001;..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\utils;.;..\cfg\eoprot-callbacks;..\src\eoappservices;..\cfg\eoappservices\icub-can-proto;..\cfg\eoappservices\icub-can-net;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\robotconfig\v1\backdoor;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\cfg\eoprot-boards;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\ems004\env\cfg;..\cfg\eoemsappl;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\libs\midware\hl-plus\api
  asm misc: --cpreproc
  asm include: ..\cfg\abslayer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-zerooffset.sct
  group main
    ../main/: eom_emsappl_main.cpp
  group abslayer-lib
    ../../../../../libs/highlevel/abslayer/ipal/lib/: ipal.base.medium.cm4.lib
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib osal.cm4.trace.lib
    ../../../../../libs/highlevel/abslayer/hal2/lib/: hal2.ems4rd.ethdbg.lib
  group abslayer-cfg
    ../cfg/abslayer/: hal_core_cfg.h ipal_cfg.h osal_cfg.h hal_core_cfg.c ipal_cfg.c osal_cfg.c hal_startup_mpu_name_stm32f407ig-v6.s
  group eo-core
    ../../../../../../../../../icub-firmware-shared/eth/embobj/core/core/: EOaction.c EOarray.c EoCommon.c EOconstarray.c EOconstvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOpacket.c EOsm.c EOtheErrorManager.c EOtheLEDpulser.c EOtheMemoryPool.c EOtimer.c EOumlsm.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c
  group eo-core-mee
    ../../../../../embobj/core/exec/multitask/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../../embobj/plus/ipnet/: EOMtheIPnet.c EOsocket.c EOsocketDatagram.c EOVtheIPnet.c
  group eo-arm-env
    ../../../../../embobj/plus/embenv/: EOtheARMenvironment.c EOVtheEnvironment.c
  group eventviewer
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group arm-services-embenv
    ../../../../../libs/highlevel/services/embenv/src/: eEcommon.c eEsharedServices.c shalBASE.c shalINFO.c shalPART.c
  group eo-emsappl
    ../../../../../embobj/plus/ctrloop/: eOcfg_sm_EMSappl.c EOMtheEMSapplCfg.c EOMtheEMSbackdoor.c EOMtheEMSbackdoortransceiver.c EOMtheEMSconfigurator.c EOMtheEMSdiscoverylistener.c EOMtheEMSdiscoverytransceiver.c EOMtheEMSerror.c EOMtheEMSrunner.c EOMtheEMSsocket.c EOMtheEMStransceiver.c EOMtheEMSappl.c
  group eo-emsappl-cfg
    ../cfg/eoemsappl/: EOMtheEMSapplCfg_cfg.h overridden_runner.c overridden_appl.c overridden_sm.c overridden_configurator.c overridden_backdoortransceiver.c overridden_error.c overridden_controller.c
  group opc-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/opcprot/: OPCprotocolManager.c
  group appl-services
    ../src/eoappservices/: EOtheServices.c EOtheVirtualStrain.c EOtheMAIS.c EOtheSTRAIN.c EOtheSKIN.c EOtheMC4boards.c EOtheCANdiscovery2.c EOtheMotionController.c EOtheETHmonitor.c EOCurrentsWatchdog.c EOwatchdog.c EOtheSharedHW.c EOtheMEMS.c EOtheInertials3.c EOtheTemperatures.c EOthePSC.c EOthePOS.c EOtheFatalError.c embot_app_eth_theFTservice.cpp embot_app_eth_theBATservice.cpp embot_app_eth_CANmonitor.cpp
    ../../../../../embobj/plus/ctrloop/: EOMtheEMSdiagnostic.cpp
    ../../../../../embobj/plus/board/: EOtheEntities.c
  group embot::app::eth::theEncoderReader
    ../../../../../embot/app/eth/: embot_app_eth_theEncoderReaderLegacy.cpp
    ../src/eoappservices/: EOtheEncoderReader.c
    ../../../../../embobj/plus/board/: EOappEncodersReader.c
  group embot::app::eth::mc
    ../../../../../embot/app/eth/: embot_app_eth_mc_messaging.cpp
  group motor-controller
    ../../../../../embobj/plus/mc/: Controller.c Calibrators.c AbsEncoder.c Joint.c JointSet.c Motor.c Pid.c Trajectory.c WatchDog.c
  group eo-comm-transport
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/transport/: EOagent.c EOconfirmationManager.c EOhostTransceiver.c EOnvSet.c EOproxy.c EOnv.c EOreceiver.c EOrop.c EOropframe.c EOtheBOARDtransceiver.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtheInfoDispatcher.c
  group eo-protocol
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/protocol/src/: EoProtocol.c EoProtocolAS_fun.c EoProtocolAS_rom.c EoProtocolEPs.c EoProtocolMC_fun.c EoProtocolMC_rom.c EoProtocolMN_fun.c EoProtocolMN_rom.c EoProtocolSK_fun.c EoProtocolSK_rom.c
    ../../../../../../../../../icub-firmware-shared/eth/embobj/plus/comm-v2/icub/: EoError.c EoBoards.c EoAnalogSensors.c EoManagement.c EoUpdaterProtocol.c EoMotionControl.c
  group eo-protocol-cfg-callbacks
    ../cfg/eoprot-callbacks/: EoProtocolMN_fun_ems4rd.c EoProtocolAS_fun_ems4rd.c EoProtocolSK_fun_ems4rd.c EoProtocolMC_fun_ems4rd.c
  group eoprot-can
    ../../../../../embobj/plus/can/: EOtheCANmapping.c EOtheCANprotocol.c EOtheCANservice.c
  group eoprot-can-cfg-protocol
    ../../../../../embobj/plus/can/config-can-protocol/: EoCANprotASperiodic.c EoCANprotASpolling.c EoCANprotMCperiodic.c EoCANprotMCpolling.c EoCANprotSKperiodic.c EoCANprotISperiodic.c EoCANprotBSperiodic.c
  group embot::core
    ../../../../../embot/cif/: embot_cif_core.cpp
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::prot::eth
    ../../../../../embot/cif/: embot_cif_diagnostic.cpp
    ../../../../../../../../../icub-firmware-shared/embot/prot/eth/: embot_prot_eth_diagnostic_Host.cpp embot_prot_eth_diagnostic_Node.cpp embot_prot_eth_rop.cpp embot_prot_eth_ropframe.cpp
  group mbd::kalman-filter
    ../../../../../mbd/kalman_filter/: kalman_filter.cpp kalman_filter_data.cpp
  group embot::prot::can
    ../../../../../embot/prot/can/: embot_prot_can.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp
  group appl-services-test
    ../src/eoappservices/: servicetester.cpp embot_app_eth_theServiceTester.cpp testRTC.c embot_app_eth_theMCserviceEOtesterconfig.cpp
  group embot-app-scope
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
    ../../../../../embot/app/: embot_app_scope.cpp
  group mbd::torque-estimator
    ../../../../../mbd/torque_estimator/: TorqueEstimator.cpp
  group mbd::ankle-decoupler
    ../../../../../mbd/ankle_decoupler/: codegen_Jacobian.cpp
target ems-trace-osal (6160000::V6.16::ARMCLANG)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: ems004 +hex
  AfterMake: cmd.exe /C copy .\Obj\ems004.hex ..\bin\ems004.hex
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: DIAGNOSTIC2_enabled DIAGNOSTIC2_receive_from_daemon DIAGNOSTIC2_send_to_yarprobotinterface _no_DIAGNOSTIC2_send_to_daemon
  c misc: -DFATALERR_trace_TMRMAN -DFATALERR_trace_RTOS -DEOTHESERVICES_disable_thePOS -Wno-pragma-pack -Wno-deprecated-register -DUSE_EMS4RD -DUSE_OLD_BUGGY_MODE_TO_SEND_UP_FULLSCALE_WITH_INVERTED_BYTES
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg\eoemsappl;..\cfg\abslayer;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\src;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\embobj\plus\board\ems001;..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\utils;.;..\cfg\eoprot-callbacks;..\src\eoappservices;..\cfg\eoappservices\icub-can-proto;..\cfg\eoappservices\icub-can-net;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\robotconfig\v1\backdoor;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\cfg\eoprot-boards;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\ems004\env\cfg;..\cfg\eoemsappl;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\embobj\plus\can;..\..\..\..\..\embobj\plus\can\config-can-mapping;..\..\..\..\..\embobj\plus\can\config-can-protocol;..\..\..\..\..\embobj\plus\board;..\..\..\..\mc4plus\appl\v2\src\eoappservices;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embot;..\..\..\..\..\embot\cif;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  link misc: --diag_suppress=L6329
target ems4rd (6160000::V6.16::ARMCLANG)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: ems004 +hex
  AfterMake: cmd.exe /C copy .\Obj\ems004.hex ..\bin\ems004.hex
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: as above
  c misc: -DTESTRTC_IS_ACTIVE -DEOTHESERVICES_disable_thePOS -Wno-pragma-pack -Wno-deprecated-register -DUSE_EMS4RD -DUSE_OLD_BUGGY_MODE_TO_SEND_UP_FULLSCALE_WITH_INVERTED_BYTES
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  link misc: --diag_suppress=L6329
target ems-ulpro (6220000::V6.22::ARMCLANG)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: ems004 +hex
  AfterMake: cmd.exe /C copy .\Obj\ems004.hex ..\bin\ems.hex
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: DIAGNOSTIC2_enabled DIAGNOSTIC2_receive_from_daemon DIAGNOSTIC2_send_to_yarprobotinterface _no_DIAGNOSTIC2_send_to_daemon SENSORLESS_TORQUE PARALLEL_ANKLE
  c misc: -DxYRI_uses_MC_foc_actuator_descriptor_generic -DxTESTRTC_IS_ACTIVE -DXenableTHESERVICETESTER  -Wno-pragma-pack -Wno-deprecated-register -DUSE_EMS4RD -DUSE_OLD_BUGGY_MODE_TO_SEND_UP_FULLSCALE_WITH_INVERTED_BYTES -DEMBOT_APP_SCOPE_core -DDEBUG_encoder_AKSIM
  c include: ..\..\..\..\..\libs\highlevel\abslayer\ipal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\core\core;..\..\..\..\..\embobj\core\exec\multitask;..\..\..\..\..\embobj\plus\embenv;..\..\..\..\..\embobj\plus\ipnet;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\..\..\libs\midware\eventviewer\api;..\cfg\eoemsappl;..\cfg\abslayer;..\..\..\..\..\embobj\plus\ctrloop;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\icub;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\protocol\src;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\transport;..\..\..\..\..\embobj\plus\board\ems001;..\..\..\..\..\embobj\plus\mc;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\utils;.;..\cfg\eoprot-callbacks;..\src\eoappservices;..\cfg\eoappservices\icub-can-proto;..\cfg\eoappservices\icub-can-net;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\robotconfig\v1\backdoor;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embobj\plus\comm-v2\opcprot;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\cfg\eoprot-boards;..\..\..\..\..\libs\highlevel\abslayer\hal2\api;..\..\..\..\ems004\env\cfg;..\cfg\eoemsappl;..\..\..\..\..\libs\highlevel\services\embodyrobot;..\..\..\..\..\libs\midware\hl-plus\api;..\..\..\..\..\embobj\plus\can;..\..\..\..\..\embobj\plus\can\config-can-mapping;..\..\..\..\..\embobj\plus\can\config-can-protocol;..\..\..\..\..\embobj\plus\board;..\..\..\..\mc4plus\appl\v2\src\eoappservices;..\..\..\..\..\..\..\..\..\icub-firmware-shared\eth\embot;..\..\..\..\..\embot\cif;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\prot\eth;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\mbd\kalman_filter;..\..\..\..\..\embot\app\eth;..\..\..\..\..\embot\prot\can;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\app;..\..\..\..\..\mbd\torque_estimator;..\..\..\..\..\mbd\ankle_decoupler
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\eApplication-v6.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.2
