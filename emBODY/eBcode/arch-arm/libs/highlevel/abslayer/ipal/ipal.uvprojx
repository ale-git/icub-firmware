# Keil uVision project ipal.uvprojx, settings and files
target ipal.full.small (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ipal.full.small (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.full.small.lib .\lib\ipal.full.small.lib
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: IPAL_MODE_FULL IPAL_MEMORY_SMALL
  c misc: --c99
  c include: ..\ipal\api;.\src\tcpnet;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ipal
    ./src/tcpnet/: ipal_arp.c ipal_base.c ipal_dhcp.c ipal_eth.c ipal_ftp.c ipal_igmp.c ipal_sys.c ipal_tcp.c ipal_telnet.c ipal_tftp.c ipal_udp.c
  group tcpnet-v4.13
    ./ipal-extra/: TCP_CM3-v413.lib
  group ipal_ipiit_storage
    ./ipal-extra/: ipal_ipiit_storage.c
target ipal.full.medium (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal.full.medium (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.full.medium.lib .\lib\ipal.full.medium.lib
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: IPAL_MODE_FULL IPAL_MEMORY_MEDIUM
  c misc: --c99
  c include: ..\ipal\api;.\src\tcpnet;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.small (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal.base.small (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal.base.small.lib .\lib\ipal.base.small.lib
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_SMALL
  c misc: --c99
  c include: ..\ipal\api;.\src\tcpnet;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.medium (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal_base_medium (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal_base_medium.lib .\lib\ipal.base.medium.lib
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_MEDIUM
  c include: ..\ipal\api;.\src\tcpnet;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.large (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: ipal_base_large (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal_base_large.lib .\lib\ipal.base.large.lib
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_LARGE
  c include: ..\ipal\api;.\src\tcpnet;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ipal.base.medium.cm4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F417IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ipal_base_medium_cm4 (library)
  AfterMake: cmd.exe /C copy .\Obj\ipal_base_medium_cm4.lib .\lib\ipal.base.medium.cm4.lib
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: IPAL_MODE_BASE IPAL_MEMORY_MEDIUM
  c include: ..\ipal\api;.\src\tcpnet;.\ipal-extra
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0
